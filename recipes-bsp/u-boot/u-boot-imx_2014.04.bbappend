FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI+="file://0001-removed-bootdelay-adjusted-mmcargs-changed-panel.patch"


